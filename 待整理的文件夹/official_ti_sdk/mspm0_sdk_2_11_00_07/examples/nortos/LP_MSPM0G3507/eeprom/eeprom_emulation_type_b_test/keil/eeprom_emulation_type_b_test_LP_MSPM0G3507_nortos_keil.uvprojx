# Keil uVision project eeprom_emulation_type_b_test_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target eeprom_emulation_type_b_test_LP_MSPM0G3507_nortos_keil (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  output: eeprom_emulation_type_b_test_LP_MSPM0G3507_nortos_keil +hex
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ../,../../../../../../source/third_party/CMSIS/Core/Include,../../../../../../source
  scatter file: ./mspm0g3507.sct
  link misc: ../../../../../../source/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../: ti_msp_dl_config.h ti_msp_dl_config.c main.c nmi_flashded_isr.c
    ../ti/eeprom/emulation_type_a/: eeprom_emulation_type_a.c eeprom_emulation_type_a.h
    ../ti/eeprom/emulation_type_b/: eeprom_emulation_type_b.c eeprom_emulation_type_b.h
    ./: startup_mspm0g350x_uvision.s
